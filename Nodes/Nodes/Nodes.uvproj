# Keil uVision project Nodes.uvproj, settings and files
target STM32F407VG (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Nodes +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: .\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Utilities\STM32F4-Discovery;..\Nodes;.\FreeRTOS\Source\include;.\Startup;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\FreeRTOS;.\STM32F4_Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: system_stm32f4xx.c startup_stm32f4xx.s
  group Main
    ./Utilities/STM32F4-Discovery/: stm32f4_discovery.c
    ./: stm32f4xx_it.c
    ./App_code/: can.c main.c UART.c
  group FreeRTOS
    ./FreeRTOS/Source/: timers.c tasks.c queue.c list.c croutine.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/: FreeRTOSConfig.h
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Dependencies
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
